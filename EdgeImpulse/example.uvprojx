# Keil uVision project example.uvprojx, settings and files
target Alif E7 M55_HP (6180000::V6.18::ARMCLANG)
  device: AE722F80F55D5AE:M55_HP Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.0.2.0
  cpu: IRAM(0x02000000,0x00400000) IRAM2(0x08000000,0x00280000) IROM(0x80000000,0x00580000) XRAM(0x50000000,0x00040000) XRAM2(0x50800000,0x00100000) XRAM3(0x60000000,0x00040000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EI_ETHOS EI_CONFIG_ETHOS_U55_256 EI_ALIF_ADDR_TRANSLATION EI_CLASSIFIER_ALLOCATION_STATIC
  c include: .\source
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x60000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\ensemble.sct
  group main
    ./source/: main.cpp ei_classifier_porting.cpp
  group tflite-model
    ./source/tflite-model/: trained_model_compiled.cpp
  group sdk
    ./source/edge-impulse-sdk/classifier/: ei_run_classifier_c.cpp
    ./source/edge-impulse-sdk/dsp/dct/: fast-dct-fft.cpp
    ./source/edge-impulse-sdk/dsp/image/: processing.cpp
    ./source/edge-impulse-sdk/dsp/: memory.cpp
  group hal
    ./source/hal/: hal.c systick.c retarget.c uart_stdout.c uart_stdout_avh.c
target Alif E7 M55_HE (6180000::V6.18::ARMCLANG)
  device: AE722F80F55D5AE:M55_HE Alif Semiconductor
  pack: AlifSemiconductor.Ensemble.0.2.0
  cpu: as above
  output: example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: EI_ETHOS EI_CONFIG_ETHOS_U55_128 EI_ALIF_ADDR_TRANSLATION EI_CLASSIFIER_ALLOCATION_STATIC
  c include: .\source
  memory RVCT4: ROM 0x80000000 size 0x580000
  memory RVCT6: RAM 0x50000000 size 0x40000
  memory RVCT7: RAM 0x50800000 size 0x100000
  memory RVCT8: RAM 0x60000000 size 0x40000
  memory RVCT9: RAM 0x2000000 size 0x400000
  memory RVCT10: RAM 0x8000000 size 0x280000
  scatter file: .\ensemble.sct
target AVH_Corstone-300_U55 (6180000::V6.18::ARMCLANG)
  device: SSE-300-MPS3 ARM
  pack: ARM.V2M_MPS3_SSE_300_BSP.1.2.0
  cpu: IRAM(0x00000000,0x00080000) IRAM2(0x01000000,0x00200000) XRAM(0x20000000,0x00020000) XRAM2(0x20020000,0x00020000) XRAM3(0x20040000,0x00020000) CPUTYPE("Cortex-M55") FPU3(DFPU) DSP TZ MVE(FP) CLOCK(12000000) ESEL ELITTLE
  output: example
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c include: .\source
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x20020000 size 0x20000
  memory RVCT8: RAM 0x20040000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x80000
  memory RVCT10: RAM 0x1000000 size 0x200000
  scatter file: .\RTE\Device\SSE-300-MPS3\fvp_sse300_mps3_s.sct
software components: CMSIS Driver:USART 1.0.0, CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev, CMSIS:NN Lib 3.0.0, Device:Definition 1.1.0, Device:Startup 1.1.0, Machine Learning:NPU Support:Ethos-U Driver 1.0.5, Native Driver:UART 1.0.0, CMSIS Driver:USART:USART 1.0.0, Device:SOC Peripherals:PINCONF 1.0.0, Device:Startup 1.0.0, Device:Startup 1.0.0, Data Exchange:Serialization:flatbuffers 1.12.0, Data Processing:Math:gemmlowp fixed-point 1.0.0, Data Processing:Math:kissfft 1.4.5, Data Processing:Math:ruy 1.12.0, Machine Learning:TensorFlow:Kernel Utils 0.4.0, Machine Learning:TensorFlow:Kernel 0.4.0
