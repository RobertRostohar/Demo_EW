# Keil uVision project Project.uvprojx, settings and files
target B-U585I-IOT02A (6180000::V6.18::ARMCLANG)
  device: STM32U585AIIx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: b_u585i_iot02a_tfm_ns +hex
  AfterMake: sign_image.bat
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=1 wLevel=3
  c define: TFM_PSA_API STM32U585xx USE_HAL_DRIVER MBEDTLS_CONFIG_FILE=\"mbedtls_config_psa.h\" LWIP_ERRNO_INCLUDE=\"lwip_errno.h\"
  c misc: -Wno-implicit-function-declaration
  c include: ..\tfm\interface\include;..\..\Application;..\..\Application\config;..\..\Application\include;..\..\Application\boards;..\..\Application\cli;..\..\Application\app\mqtt;..\..\Application\net\lwip_port\include;..\..\Application\kvstore;..\..\Drivers\BSP\B-U585I-IOT02A;..\..\Drivers\CMSIS\Core\Include;..\..\Drivers\CMSIS\Device\ST\STM32U5xx\Include;..\..\Drivers\CommonIO\include;..\..\Drivers\CommonIO\gpio;..\..\Drivers\STM32U5xx_HAL\Inc;..\..\Middleware\FreeRTOS\backoffAlgorithm\source\include;..\..\Middleware\FreeRTOS\coreJSON\source\include;..\..\Middleware\FreeRTOS\coreMQTT\source\include;..\..\Middleware\FreeRTOS\coreMQTT\source\interface;..\..\Middleware\FreeRTOS\coreMQTT-Agent\source\include;..\..\Middleware\FreeRTOS\kernel\include;..\..\Middleware\FreeRTOS\kernel\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\Middleware\AWS\IoTDeviceDefender\source\include;..\..\Middleware\AWS\IoTDeviceShadow\source\include;..\..\Middleware\AWS\OTA\source\include;..\..\Middleware\AWS\OTA\source\portable\os;..\..\Middleware\lwip\src\include;..\..\Middleware\tinycbor\src;..\..\Middleware\ARM\mbedtls\include;..\..\Middleware\ARM\mbedtls\library;..\..\Middleware\ARM\ota-pal-psa
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\stm32u5xx_ns.sct
  group app
    ../../Application/app/: app_main.c env_sensor_publish.c motion_sensors_publish.c shadow_device_task.c mbedtls_entropy_alt_psa.c startup_stm32u5xx_ns.c system_stm32u5xx_ns.c tfm_ns_interface_freertos.c
    ../../Application/app/defender/: defender_task.c metrics_collector_lwip.c
    ../../Application/app/mqtt/: freertos_command_pool.c mqtt_agent_task.c
    ../../Application/app/ota/: ota_update_task.c
  group boards
    ../../Application/boards/: stm32u5_iot_board.c
  group cli
    ../../Application/cli/: cli_conf.c cli_main.c cli_pki.c cli_rngtest.c cli_uart_drv.c cli_utils.c logging.c
  group config
    ../../Application/config/: b_u585i_iot02a_conf.h core_http_config.h core_mqtt_config.h defender_config.h FreeRTOSConfig.h hw_defs.h kvstore_config.h lwipopts.h mqtt_metrics.h ota_config.h shadow_config.h stm32u5xx_hal_conf.h tls_transport_lwip.h
  group crypto
    ../../Application/crypto/: mbedtls_pk_pkcs11.c mbedtls_pk_psa.c PkiObject.c PkiObjectPkcs11.c PkiObjectPsa.c psa_util.c
  group kvstore
    ../../Application/kvstore/: kvstore.c kvstore_cache.c kvstore_nv_psa_its.c
  group net
    ../../Application/net/: mbedtls_transport.c
    ../../Application/net/lwip_port/src/: sys_arch.c
    ../../Application/net/mxchip/: mx_dataplane.c mx_ipc.c mx_lwip.c mx_netconn.c
  group sys
    ../../Application/sys/: hal_init.c interrupt_handlers.c mbedtls_freertos_port.c clib_arm.c clib_stubs.c retarget_io.c
  group bsp
    ../../Drivers/BSP/B-U585I-IOT02A/: b_u585i_iot02a.c b_u585i_iot02a_bus.c b_u585i_iot02a_env_sensors.c b_u585i_iot02a_motion_sensors.c
    ../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../Drivers/BSP/Components/iis2mdc/: iis2mdc.c iis2mdc_reg.c
    ../../Drivers/BSP/Components/ism330dhcx/: ism330dhcx.c ism330dhcx_reg.c
    ../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
  group STM32U5xx_HAL
    ../../Drivers/STM32U5xx_HAL/Src/: stm32u5xx_hal.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dcache.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_iwdg.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_wwdg.c
  group lib:FreeRTOS:backoffAlgorithm
    ../../Middleware/FreeRTOS/backoffAlgorithm/source/: backoff_algorithm.c
  group lib:FreeRTOS:coreJSON
    ../../Middleware/FreeRTOS/coreJSON/source/: core_json.c
  group lib:FreeRTOS:coreMQTT
    ../../Middleware/FreeRTOS/coreMQTT/source/: core_mqtt.c core_mqtt_serializer.c core_mqtt_state.c
  group lib:FreeRTOS:coreMQTTAgent
    ../../Middleware/FreeRTOS/coreMQTT-Agent/source/: core_mqtt_agent.c core_mqtt_agent_command_functions.c
  group lib:FreeRTOS:kernel
    ../../Middleware/FreeRTOS/kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../../Middleware/FreeRTOS/kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../Middleware/FreeRTOS/kernel/portable/MemMang/: heap_4.c
  group lib:AWS:deviceDefender
    ../../Middleware/AWS/IoTDeviceDefender/source/: defender.c
  group lib:AWS:deviceShadow
    ../../Middleware/AWS/IoTDeviceShadow/source/: shadow.c
  group lib:AWS:OTA
    ../../Middleware/AWS/OTA/source/: ota.c ota_base64.c ota_cbor.c ota_interface.c ota_mqtt.c
    ../../Middleware/AWS/OTA/source/portable/os/: ota_os_freertos.c
  group lib:libc
    ../../Middleware/libc/: strnlen.c strnstr.c stpncpy.c
  group lib:lwip
    ../../Middleware/lwip/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../Middleware/lwip/src/apps/lwiperf/: lwiperf.c
    ../../Middleware/lwip/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middleware/lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middleware/lwip/src/core/ipv6/: dhcp6.c ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c
    ../../Middleware/lwip/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group lib:tinycbor
    ../../Middleware/tinycbor/src/: cborencoder.c cborencoder_close_container_checked.c cborencoder_float.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborparser_float.c cborpretty.c cborpretty_stdio.c cbortojson.c cborvalidation.c
  group lib:mbedtls
    ../../Middleware/ARM/mbedtls/library/: aes.c aesni.c aria.c asn1parse.c asn1write.c base64.c bignum.c camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c mps_reader.c mps_trace.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_alt_helpers.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_srv.c ssl_ticket.c ssl_tls.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c
  group lib:ota-pal-psa
    ../../Middleware/ARM/ota-pal-psa/: ota_pal.c
  group lib:tfm
    ../tfm/interface/src/: tfm_crypto_ipc_api.c tfm_firmware_update_ipc_api.c tfm_initial_attestation_ipc_api.c tfm_its_ipc_api.c tfm_platform_ipc_api.c tfm_ps_ipc_api.c tfm_psa_ns_api.c
    ../tfm/interface/lib/: s_veneers.o
